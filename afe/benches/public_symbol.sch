v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Consumer fixture: labels land on the printed pin locations, not on a generated pin list.} 60 40 0 0 0.3 0.3 {}
C {tbci_native_input.sym} 300 240 0 0 {name=xdut}
C {devices/iopin.sym} 160 170 0 1 {name=p1 lab=rail}
C {devices/iopin.sym} 160 200 0 1 {name=p2 lab=ret}
C {devices/ipin.sym} 160 230 0 0 {name=p3 lab=mid}
C {devices/iopin.sym} 160 260 0 1 {name=p4 lab=bias}
C {devices/ipin.sym} 160 290 0 0 {name=p5 lab=plus_in}
C {devices/ipin.sym} 160 320 0 0 {name=p6 lab=minus_in}
C {devices/opin.sym} 440 220 0 0 {name=p7 lab=plus_out}
C {devices/opin.sym} 440 260 0 0 {name=p8 lab=minus_out}
